# Keil uVision project minidevice.uvproj, settings and files
target Aramok (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: minidevice
  c flags: Optim=1
  c define: STM32F10X_MD_VL , USE_STDPERIPH_DRIVER
  c include: ..\inc;..\startup;..\sensor_library
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./: main.c
  group library
    ../src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_flash.c
  group Startup
    ../startup/: system_stm32f10x.c startup_stm32f10x_md_vl.s
  group Sensors
    ../sensor_library/: sht11.c hih5031.c lcd_display.c flash.c armenu.c
